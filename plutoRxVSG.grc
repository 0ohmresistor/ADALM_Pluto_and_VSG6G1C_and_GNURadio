options:
  parameters:
    author: Tomsov Vsevolod
    generate_options: qt_gui
    id: pluto_plutoTRx
    output_language: python
    title: Receive QPSK from TSG
  states: {}

blocks:
- name: RootRaisedCosineTaps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: nFilter
    ntaps: 11*sps*nFilter
    samp_rate: nFilter*1000000
    sym_rate: '100000'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    sym_map: '[0, 1, 2, 3]'
    type: qpsk
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '999900000'
    step: '100'
    stop: '1001000000'
    value: '1000000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '72'
    value: '23'
  states: {}
- name: nFilter
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: constellation
    fmax: math.pi
    fmin: '-math.pi'
    loop_bw: 2*math.pi/100
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: sps*2
    rolloff: '0.5'
    samps_per_sym: sps
    type: cc
    w: 2*math.pi/sps/100
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constellation
    damping: '1.25'
    loop_bw: '0.45'
    max_dev: '0.1'
    nfilters: nFilter
    osps: '1'
    pfb_mf_taps: RootRaisedCosineTaps
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: cc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '700000'
    bbdc: 'False'
    buffer_size: '500000'
    filter_source: '''Off'''
    frequency: frequency
    gain1: '''manual'''
    manual_gain1: gain
    quadrature: 'True'
    rfdc: 'False'
    samplerate: '6000000'
    type: fc32
    uri: usb:1.8.5
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    label1: Sync
    name: '"With filter"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: '5'
    size: '1024'
    srate: '6000000'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '30000000'
    fc: '1000000000'
    fftsize: '1024'
    grid: 'True'
    name: '"source//FLL"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    label1: Constellation Receiver Decoded
    marker1: '0'
    size: '100'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Constellation Receiver Decoded
    label2: Costas Im
    marker1: '0'
    marker2: '0'
    size: '100'
    srate: samp_rate
    type: complex
    ymax: '2'
  states: {state: disabled}

connections:
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_1_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_null_sink_0_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0_0, '0']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_1, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_eye_sink_x_0, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_time_sink_x_0_0_0_0_0_0_1_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [iio_pluto_source_0, '0', digital_fll_band_edge_cc_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
